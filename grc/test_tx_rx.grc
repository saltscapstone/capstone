<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>150000</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>serial=4a54d7c8</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>60000</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>10000</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/ubuntu/input</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>digital_ofdm_mod</key>
<param><key>id</key><value>digital_ofdm_mod_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>modulation</key><value>qpsk</value></param>
<param><key>fft_length</key><value>1024</value></param>
<param><key>occupied_tones</key><value>200</value></param>
<param><key>cp_length</key><value>128</value></param>
<param><key>pad_for_usrp</key><value>True</value></param>
<param><key>payload_length</key><value>0</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>serial=4925e275</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>60000</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>10000</value></param>
</block>
<block>
<key>digital_ofdm_demod</key>
<param><key>id</key><value>digital_ofdm_demod_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>modulation</key><value>qpsk</value></param>
<param><key>fft_length</key><value>1024</value></param>
<param><key>occupied_tones</key><value>200</value></param>
<param><key>cp_length</key><value>128</value></param>
<param><key>snr</key><value>10</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>60000</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/capstone/output</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<connection><source_block_id>digital_ofdm_mod_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>digital_ofdm_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_demod_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>digital_ofdm_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
